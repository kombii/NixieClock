# Keil uVision project clock.uvprojx, settings and files
target clock (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: clock
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\32f103c8_fwlib;..\core;..\obj;..\32f103c8_fwlib\inc;..\mycode;.\hardware;.\program;.\mbed\mbed;.\mbed\mbed\TARGET_NUCLEO_F103RB;.\mbed\mbed\TARGET_NUCLEO_F103RB\TARGET_STM;.\mbed\mbed\TARGET_NUCLEO_F103RB\TARGET_STM\TARGET_STM32F1;.\mbed\mbed\TARGET_NUCLEO_F103RB\TARGET_STM\TARGET_STM32F1\device;.\mbed\mbed\TARGET_NUCLEO_F103RB\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB;.\mbed\mbed\TARGET_NUCLEO_F103RB\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB\device;.\mbed\mbed\TARGET_NUCLEO_F103RB\TOOLCHAIN_ARM_STD;.\mbed\mbed\drivers;.\mbed\mbed\hal;.\mbed\mbed\platform
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./program/: Display.c main.c delay.c
  group hardware
    ./program/: usart1.c i2c.c ds3231.c
    ./hardware/: HV57708.c
  group core
    ./: system_stm32f10x.c stm32f10x_it.c
    ../core/: core_cm3.c startup_stm32f10x_md.s
  group 32fwlib
    ../32f103c8_fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
